v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -500 -160 -420 -160 {
lab=#net1}
C {SUN_SAR9B_SKY130NM/SUNSAR_SAR9B_CV.sym} -400 -160 0 0 {name=x1}
C {RPLY_TEMP_SENS_SKY130NM/TEMP_SENS_ELEMENT.sym} -650 -150 0 0 {name=x2}
C {devices/lab_pin.sym} -420 -60 0 0 {name=D8 sig_type=std_logic lab=D8}
C {devices/lab_pin.sym} -420 -40 0 0 {name=D7 sig_type=std_logic lab=D7}
C {devices/lab_pin.sym} -420 -20 0 0 {name=D6 sig_type=std_logic lab=D6}
C {devices/lab_pin.sym} -420 0 0 0 {name=D5 sig_type=std_logic lab=D5}
C {devices/lab_pin.sym} -420 20 0 0 {name=D4 sig_type=std_logic lab=D4}
C {devices/lab_pin.sym} -420 40 0 0 {name=D3 sig_type=std_logic lab=D3}
C {devices/lab_pin.sym} -420 60 0 0 {name=D2 sig_type=std_logic lab=D2}
C {devices/lab_pin.sym} -420 80 0 0 {name=D1 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} -420 100 0 0 {name=D0 sig_type=std_logic lab=D0}
C {devices/lab_pin.sym} -420 -140 0 0 {name=VSS sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -420 -80 0 0 {name=DONE sig_type=std_logic lab=DONE}
C {devices/lab_pin.sym} -420 120 0 0 {name=VDD_1V8 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_pin.sym} -420 200 0 0 {name=VDD_1V8 sig_type=std_logic lab=VDD_1V8}
C {devices/lab_pin.sym} -420 220 0 0 {name=VSS sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -800 -140 0 0 {name=VSS sig_type=std_logic lab=VSS}
C {devices/lab_pin.sym} -800 -160 0 0 {name=VDD_1V8 sig_type=std_logic lab=VDD_1V8}
C {devices/opin.sym} -120 -60 0 0 {name=D0 lab=D0}
C {devices/opin.sym} -120 -40 0 0 {name=D1 lab=D1}
C {devices/opin.sym} -120 -20 0 0 {name=D2 lab=D2}
C {devices/opin.sym} -120 0 0 0 {name=D3 lab=D3}
C {devices/opin.sym} -120 20 0 0 {name=D4 lab=D4}
C {devices/opin.sym} -120 40 0 0 {name=D5 lab=D5}
C {devices/opin.sym} -120 60 0 0 {name=D6 lab=D6}
C {devices/opin.sym} -120 80 0 0 {name=D7 lab=D7}
C {devices/opin.sym} -120 100 0 0 {name=D8 lab=D8}
C {devices/opin.sym} -120 -80 0 0 {name=DONE lab=DONE}
C {/opt/eda/share/xschem/xschem_library/devices/ipin.sym} -850 10 0 0 {name=VDD_1V8 lab=VDD_1V8}
C {devices/lab_pin.sym} -420 180 0 0 {name=VDD_1V8 sig_type=std_logic lab=VDD_1V8}
C {/opt/eda/share/xschem/xschem_library/devices/ipin.sym} -850 30 0 0 {name=VSS lab=VSS}
C {/opt/eda/share/xschem/xschem_library/devices/ipin.sym} -850 50 0 0 {name=CLK lab=CLK}
C {devices/lab_pin.sym} -420 140 0 0 {name=CLK sig_type=std_logic lab=CLK}
