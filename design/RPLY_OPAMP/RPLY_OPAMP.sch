v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 340 -80 0 0 {name=VO lab=VO
}
C {devices/iopin.sym} 240 -160 3 0 {name=VDD_1V8 lab=VDD_1V8
}
C {devices/iopin.sym} 340 20 0 0 {name=VIN lab=VIN}
C {devices/iopin.sym} 240 120 1 0 {name=VSS lab=VSS
}
C {devices/iopin.sym} 150 20 2 0 {name=VIP lab=VIP

}
C {devices/iopin.sym} 150 -160 3 0 {name=IBP_2U lab=IBP_2U

}
C {devices/iopin.sym} 150 -80 2 0 {name=PWRUP_1V8 lab=PWRUP_1V8
}
