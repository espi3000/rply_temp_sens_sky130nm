v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 340 -80 0 0 {name=Vout lab=Vout
}
C {devices/iopin.sym} 240 -160 3 0 {name=VDD lab=VDD
}
C {devices/iopin.sym} 340 20 0 0 {name=Vinn
 lab=Vinn}
C {devices/iopin.sym} 240 120 1 0 {name=VSS lab=VSS
}
C {devices/iopin.sym} 150 20 2 0 {name=Vinp lab=Vinp

}
